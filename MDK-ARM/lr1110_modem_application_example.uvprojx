# Keil uVision project lr1110_modem_application_example.uvprojx, settings and files
target lr1110_modem_tracker_EU868 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: lr1110_modem_application_examples +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32L476xx,LR1110EVK, USE_REGION_EU868
  c misc: --gnu
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/lis2de12/;..\Inc\boards;..\Inc\system;..\Src\radio\lr1110_modem\src;..\Src\radio;..\Drivers\EEPROM_Emul\Core;..\Drivers\EEPROM_Emul\Porting\STM32L4;..\Src\apps\update-firmware;..\Src\radio\lr1110_trx;../Drivers/BSP/Components/Leds;..\Inc\smtc_hal;..\Src\radio\wifi;..\Src\radio\gnss;..\Drivers\BSP\Components\external_supply
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/apps/LoRaWAN/: main_lorawan.c
    ../Src/apps/update-firmware/: update_firmware.c
    ../Src/apps/wifi_test/: main_test_wifi.c
    ../Src/apps/gnss_test/: main_test_gnss.c
    ../Src/apps/Tracker/: main_tracker.c
    ../Src/apps/tx_continuous_test/: main_test_tx_continuous.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_ll_rtc.c stm32l4xx_ll_spi.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Components
    ../Drivers/BSP/Components/lis2de12/: lis2de12.c
    ../Drivers/BSP/Components/Leds/: leds.c
    ../Drivers/BSP/Components/external_supply/: external_supply.c
  group tracker_utility
    ../Src/apps/Tracker/: tracker_utility.c
  group Wi-Fi Scan
    ../Src/radio/wifi/: wifi_scan.c
  group GNSS Scan
    ../Src/radio/gnss/: gnss_scan.c
  group lr1110 Modem
    ../Src/radio/: lr1110.c lr1110_modem_hal.c
    ../Src/radio/lr1110_modem/src/: lr1110_bootloader.c lr1110_modem_gnss.c lr1110_modem_lorawan.c lr1110_modem_system.c lr1110_modem_wifi.c lr1110_radio.c lr1110_regmem.c
  group Board
    ../Src/boards/: lr1110-modem-board.c utilities.c
  group smtc_hal
    ../Src/smtc_hal/: smtc_hal_gpio.c smtc_hal_i2c.c smtc_hal_mcu.c smtc_hal_rng.c smtc_hal_rtc.c smtc_hal_spi.c smtc_hal_tmr.c smtc_hal_uart.c smtc_hal_watchdog.c smtc_hal_tmr_list.c
target lr1110_modem_tracker_US915 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: lr1110_modem_application_examples +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32L476xx,USE_MODEM_LORA,LR1110EVK, USE_REGION_US915
  c misc: --gnu
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/Components/lis2de12/;..\Inc\boards;..\Inc\system;..\Src\radio\lr1110_modem\src;..\Src\radio;..\Drivers\EEPROM_Emul\Core;..\Drivers\EEPROM_Emul\Porting\STM32L4;..\Src\apps\update-firmware;..\Src\radio\lr1110_trx;../Drivers/BSP/Components/Leds;..\Inc\smtc_hal;..\Src\radio\wifi;..\Src\radio\gnss;../Drivers/BSP/Components/external_supply;../Drivers/BSP/Components/lis2de12
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target lr1110_modem_LoRaWAN_EU868 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: lr1110_modem_application_examples +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32L476xx,USE_MODEM_LORA,LR1110EVK, USE_REGION_EU868
  c misc: --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target lr1110_modem_LoRaWAN_US915 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: lr1110_modem_application_examples +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target lr1110_modem_gnss_example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: lr1110_modem_application_examples +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target lr1110_modem_wifi_example (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: lr1110_modem_application_examples +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target lr1110_modem_tx_continuous (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: lr1110_modem_application_examples +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target lr1110_modem_update_modem_to_modem (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: lr1110_modem_application_examples +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32L476xx,USE_MODEM_LORA,LR1110EVK, USE_REGION_EU868,MODEM_TO_MODEM
  c misc: --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target lr1110_modem_update_modem_to_trx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: lr1110_modem_application_examples +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32L476xx,USE_MODEM_LORA,LR1110EVK, USE_REGION_EU868,TRX_TO_MODEM
  c misc: --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
target lr1110_modem_update_trx_to_modem (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: as above
  output: lr1110_modem_application_examples +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
software components: CMSIS:CORE 4.3.0
